# IAR project iarproject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: Rtos; Rtos\wrapper; Rtos\wrapper\FreeRtos; Rtos\FreeRtos; Rtos\FreeRtos\include; Rtos\FreeRtos\portable; Rtos\FreeRtos\portable\Common; Rtos\FreeRtos\portable\IAR; Rtos\FreeRtos\portable\IAR\ARM_CM4F; Rtos\FreeRtos\portable\MemMang; MyTasks; Common; CMSIS; Application; Application\Diagnostic; AHardware; AHardware\GpioPort; AHardware\IrqController; ..\CortexLib\AbstractHardware\Pin; ..\CortexLib\AbstractHardware\Registers\STM32F411\FieldValues; ..\CortexLib\AbstractHardware\Registers\STM32F411; ..\CortexLib\AbstractHardware\Registers; ..\CortexLib\AbstractHardware\Port; ..\CortexLib\AbstractHardware\Atomic; ..\CortexLib\Common; ..\CortexLib\Common\Singleton; ..\CortexLib\Common\RomObject; AHardware\Registers; AHardware\Registers\CortexM4; AHardware\Registers\CortexM4\FieldValues; AHardware\Registers\STM32F411\FieldValues; Common; AHardware\Atomic; AHardware\USART; Tasks; Application\Button; Application; AHardware\Timer; AHardware; AHardware\Registers\STM32F411; AHardware\Registers\IrqController; AHardware\Button; AHardware\ButtonPoll; AHardware\ITransmit; AHardware\LCDDriver; AHardware\SMBus; AHardware\SPIx; AHardware\TempSens; AHardware\Timer; AHardware\UART; AHardware\UARTDriver; Application\Filter; Application\Tasks; Application\Tasks\BlueToothTask; Application\Tasks\ScreenTask; Application\Tasks\TemperatureTask; Application\Temp; Application\Temp\Temp; Application\Temp\Units; AHardware\InterruptHandler; $PROJ_DIR$; AHardware\Temp; Common; AHardware\LCDDriver\Fonts; AHardware\Pin; AHardware\Port; AHardware\Atomic; AHardware\LCDDriver; AHardware\Filter
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: Rtos; Rtos\FreeRtos; Rtos\FreeRtos\include; Rtos\FreeRtos\portable\IAR; Rtos\FreeRtos\portable\IAR\ARM_CM4F; Rtos\wrapper\FreeRtos; Rtos\wrapper
  OBJCOPY.OOCOutputFile: iarproject.srec
  ILINK.IlinkOutputFile: iarproject.out
  ILINK.IlinkIcfFile: stm32f411xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: main.cpp startupF411RE.cpp
  group AHardware/Atomic
    AHardware/Atomic/: atomicutils.hpp
  group AHardware/Button
    AHardware/Button/: Button.hpp
  group AHardware/ButtonPoll
    AHardware/ButtonPoll/: ButtonPoll.hpp
  group AHardware/Filter
    AHardware/Filter/: filter.hpp
  group AHardware/ITransmit
    AHardware/ITransmit/: Itransmit.h
  group AHardware/LCDDriver
    AHardware/LCDDriver/: Display.hpp elinkdriver.hpp systemclock.hpp
  group AHardware/LCDDriver/Fonts
    AHardware/LCDDriver/Fonts/: font.h font.hpp font24.cpp font48.cpp font_segoeUISemibold_24pt.h font_segoeUISemibold_48pt.h segoeUISemibold_24pt.h
  group AHardware/Pin
    AHardware/Pin/: pin.hpp
  group AHardware/Port
    AHardware/Port/: port.hpp
  group AHardware/Registers
    AHardware/Registers/: accessmode.hpp fieldvalue.hpp fieldvaluebase.hpp register.hpp registerbase.hpp registerfield.hpp registertype.hpp
  group AHardware/Registers/CortexM4
    ../../Laba_inf/RtosWrapper/AHardware/CortexM4/: fpucpacrregisters.hpp fpuregisters.hpp mpuregisters.hpp nvicregisters.hpp nvicstirregisters.hpp scbactrlregisters.hpp scbregisters.hpp
    AHardware/Registers/CortexM4/: stkregisters.hpp
  group AHardware/Registers/CortexM4/FieldValues
    ../../Laba_inf/RtosWrapper/AHardware/CortexM4/FieldValues/: fpucpacrfieldvalues.hpp fpufieldvalues.hpp mpufieldvalues.hpp nvicfieldvalues.hpp nvicstirfieldvalues.hpp scbactrlfieldvalues.hpp scbfieldvalues.hpp
    AHardware/Registers/CortexM4/FieldValues/: stkfieldvalues.hpp
  group AHardware/Registers/STM32F411
    AHardware/Registers/STM32F411/: adc1registers.hpp adccommonregisters.hpp crcregisters.hpp dbgregisters.hpp dma1registers.hpp dma2registers.hpp extiregisters.hpp flashregisters.hpp fpucpacrregisters.hpp fpuregisters.hpp gpioaregisters.hpp gpiobregisters.hpp gpiocregisters.hpp gpiodregisters.hpp gpioeregisters.hpp gpiohregisters.hpp i2c1registers.hpp i2c2registers.hpp i2c3registers.hpp i2s2extregisters.hpp i2s3extregisters.hpp iwdgregisters.hpp mpuregisters.hpp nvicregisters.hpp nvicstirregisters.hpp otgfsdeviceregisters.hpp otgfsglobalregisters.hpp otgfshostregisters.hpp otgfspwrclkregisters.hpp portslist.hpp pwrregisters.hpp rccregisters.hpp rtcregisters.hpp scbactrlregisters.hpp scbregisters.hpp sdioregisters.hpp spi1registers.hpp spi2registers.hpp spi3registers.hpp spi4registers.hpp spi5registers.hpp stkregisters.hpp syscfgregisters.hpp tim10registers.hpp tim11registers.hpp tim1registers.hpp tim2registers.hpp tim3registers.hpp tim4registers.hpp tim5registers.hpp tim8registers.hpp tim9registers.hpp usart1registers.hpp usart2registers.hpp usart6registers.hpp wwdgregisters.hpp
  group AHardware/Registers/STM32F411/FieldValues
    AHardware/Registers/STM32F411/FieldValues/: adc1fieldvalues.hpp adccommonfieldvalues.hpp crcfieldvalues.hpp dbgfieldvalues.hpp dma1fieldvalues.hpp dma2fieldvalues.hpp extifieldvalues.hpp flashfieldvalues.hpp fpucpacrfieldvalues.hpp fpufieldvalues.hpp gpioafieldvalues.hpp gpiobfieldvalues.hpp gpiocfieldvalues.hpp gpiodfieldvalues.hpp gpioefieldvalues.hpp gpiohfieldvalues.hpp i2c1fieldvalues.hpp i2c2fieldvalues.hpp i2c3fieldvalues.hpp i2s2extfieldvalues.hpp i2s3extfieldvalues.hpp iwdgfieldvalues.hpp mpufieldvalues.hpp nvicfieldvalues.hpp nvicstirfieldvalues.hpp otgfsdevicefieldvalues.hpp otgfsglobalfieldvalues.hpp otgfshostfieldvalues.hpp otgfspwrclkfieldvalues.hpp pwrfieldvalues.hpp rccfieldvalues.hpp rtcfieldvalues.hpp scbactrlfieldvalues.hpp scbfieldvalues.hpp sdiofieldvalues.hpp spi1fieldvalues.hpp spi2fieldvalues.hpp spi3fieldvalues.hpp spi4fieldvalues.hpp spi5fieldvalues.hpp stkfieldvalues.hpp syscfgfieldvalues.hpp tim10fieldvalues.hpp tim11fieldvalues.hpp tim1fieldvalues.hpp tim2fieldvalues.hpp tim3fieldvalues.hpp tim4fieldvalues.hpp tim5fieldvalues.hpp tim8fieldvalues.hpp tim9fieldvalues.hpp usart1fieldvalues.hpp usart2fieldvalues.hpp usart6fieldvalues.hpp wwdgfieldvalues.hpp
  group AHardware/SMBus
    AHardware/SMBus/: SMBus.hpp
  group AHardware/SPIx
    AHardware/SPIx/: spi.hpp
  group AHardware/Temp
    AHardware/Temp/: Celsius.hpp Fahrenheit.hpp IUnits.hpp Kelvin.hpp Temp.hpp
  group AHardware/TempSens
    AHardware/TempSens/: TempSens.hpp
  group AHardware/Timer
    AHardware/Timer/: Timer.cpp Timer.hpp
  group AHardware/UART
    AHardware/UART/: usart.h usartconfig.h
  group AHardware/UARTDriver
    AHardware/UARTDriver/: USARTDriver.h
  group Application/Tasks/BlueToothTask
    Application/Tasks/BlueToothTask/: BlueToothTask.hpp
  group Application/Tasks/ScreenTask
    Application/Tasks/ScreenTask/: ScreenTask.hpp
  group Application/Tasks/TemperatureTask
    Application/Tasks/TemperatureTask/: TemperatureTask.hpp
  group Common
    Common/: susudefs.hpp utils.hpp
  group Rtos/FreeRtos
    Rtos/FreeRtos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Rtos/FreeRtos/portable/Common
    Rtos/FreeRtos/portable/Common/: mpu_wrappers.c
  group Rtos/FreeRtos/portable/IAR/ARM_CM4F
    Rtos/FreeRtos/portable/IAR/ARM_CM4F/: port.c portasm.c portasm.s
  group Rtos/FreeRtos/portable/MemMang
    Rtos/FreeRtos/portable/MemMang/: heap_1.c
  group Rtos/wrapper
    Rtos/wrapper/: criticalsection.hpp event.hpp eventmode.hpp interruptentry.hpp mailbox.hpp mutex.hpp rtos.hpp thread.hpp
  group Rtos/wrapper/FreeRtos
    Rtos/wrapper/FreeRtos/: rtosdefs.hpp rtoswrapper.hpp
